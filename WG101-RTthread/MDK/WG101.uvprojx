# Keil uVision project WG101.uvprojx, settings and files
target WG101 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32L130J8TA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: WG101 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\driver_file\inc;..\mcu_file;..\MDK;..\os_file;..\user_file\inc;..\driver_file\src;..\user_file\inc;..\os_file\include;..\os_file\libcpu\arm\cortex-m0
  asm include: ..\driver_file\src;..\MDK;..\driver_file\inc;..\mcu_file;..\MDK;..\user_file\inc;..\os_file\libcpu\arm\cortex-m0
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../mcu_file/: interrupts_hc32l13x.c
    ../user_file/: main.c
    ../user_file/src/: init.c
  group Driver
    ../driver_file/src/: flash.c gpio.c lpm.c lptim.c lpuart.c reset.c rtc.c sysctrl.c timer3.c uart.c wdt.c ddl.c spi.c
  group Common
    ./: startup_hc32l13x.s
    ../mcu_file/: system_hc32l13x.c
    ../user_file/src/: global_variable.c
  group Kernel
    ../os_file/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../os_file/: board.c rtconfig.h
    ../os_file/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
software components: CMSIS:CORE 5.5.0
