# Keil uVision project WG101.uvprojx, settings and files
target WG101 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32L130J8TA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: WG101 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\driver_file\inc;..\mcu_file;..\MDK;..\os_file;..\user_file\inc;..\driver_file\src;..\user_file\inc;.\RTE\RTOS;..\MiddleLayer
  asm include: ..\driver_file\src;..\MDK;..\driver_file\inc;..\mcu_file;..\MDK;..\user_file\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../mcu_file/: interrupts_hc32l13x.c
    ../user_file/: main.c
    ../user_file/src/: init.c global_variable.c
    ../user_file/inc/: global_variable.h
  group Driver
    ../driver_file/src/: flash.c gpio.c lpm.c lptim.c lpuart.c reset.c rtc.c sysctrl.c timer3.c uart.c wdt.c ddl.c spi.c adc.c
    ../../WG101/driver_file/src/: bgr.c
  group Common
    ./: startup_hc32l13x.s
    ../mcu_file/: system_hc32l13x.c
  group Kernel
    ../os_file/: FrameWork.c
  group MiddleLayer
    ../MiddleLayer/: Logic.c ScanKEY.c LCDDriver.c RTCFun.c Save.c
software components: CMSIS:CORE 5.4.0
